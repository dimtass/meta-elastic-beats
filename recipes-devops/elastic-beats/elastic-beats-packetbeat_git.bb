DESCRIPTION = "Compile Elastic packetbeat."

require elastic-beats.inc

DEPENDS = "libpcap"

GO_PACKAGE = "packetbeat"