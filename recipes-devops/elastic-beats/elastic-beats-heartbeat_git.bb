DESCRIPTION = "Compile Elastic heartbeat."

require elastic-beats.inc

GO_PACKAGE = "heartbeat"