DESCRIPTION = "Compile Elastic auditbeat."

require elastic-beats.inc

DEPENDS = "libpcap"

GO_PACKAGE = "auditbeat"