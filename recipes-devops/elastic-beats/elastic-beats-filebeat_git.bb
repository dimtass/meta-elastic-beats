DESCRIPTION = "Compile Elastic filebeat."

require elastic-beats.inc

GO_PACKAGE = "filebeat"